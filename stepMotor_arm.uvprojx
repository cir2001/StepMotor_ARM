# Keil uVision project stepMotor_arm.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stepMotor_arm
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_LD
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\ADC;.\HARDWARE\PORT;.\HARDWARE\SPI;.\HARDWARE\SYSTICK;.\HARDWARE\TIMER;.\HARDWARE\LED;.\HARDWARE\STMFLASH;.\USER;.\HARDWARE\EXTI;.\HARDWARE\OLED;.\HARDWARE\CAN;.\HARDWARE\AS5600;.\HARDWARE\STEPMOTOR
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./USER/: startup_stm32f10x_ld.s
  group USER
    ./: stepMotor_ArmV5.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/PORT/: port.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/STMFLASH/: stmflash.c
    ./HARDWARE/SYSTICK/: systick.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/EXTI/: exti.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/AS5600/: AS5600.c myiic.c
    ./HARDWARE/STEPMOTOR/: stepMotor.c
